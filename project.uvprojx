# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Library;.\System;.\Hardware;.\bsp;.\app;.\module;.\Wj;.\Wj\app;.\Wj\bsp;.\Jia;.\Jia\My\ATK_IMU901;.\Jia\My\Delay;.\Jia\My\OLED;.\Jia\My\PS2;.\Jia\My\Slave1;.\Jia\My\UART;.\Jia\My
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group JiaJia
    ./Jia/My/Delay/: Delay_API_z.h Delay_z.c
    ./Jia/My/OLED/: OLED.c OLED_API.h OLED_Demo.c OLED_Demo.h OLED_Font.h OLED_Func.h OLED_I2C_API.h
    ./Jia/My/PS2/: PS2.c PS2_API.h PS2_Def.h PS2_Demo.c PS2_Demo.h PS2_Func.h PS2_SPI_API.h
    ./Jia/My/Slave1/: PS2ToSlave1.c PS2ToSlave1_API.h PS2ToSlave1_Demo.c PS2ToSlave1_Demo.h
    ./Jia/My/UART/: UART_API_z.h UART_Def_z.h UART_Demo_z.c UART_Demo_z.h UART_Func_z.h UART_z.c
    ./Jia/My/: Incl_z.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Wj
    ./Wj/app/: Chassis.c Chassis.h PID.c PID.h
    ./Wj/bsp/: bsp_ChassisEncoder.c bsp_ChassisEncoder.h bsp_motorTIM.c bsp_motorTIM.h
